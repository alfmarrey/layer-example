FILESEXTRAPATHS_prepend := "${THISDIR}/${BP}:"
SRC_URI_append_ccimx6ulsbc = " file://0001-keeping-3V3_ext-enabled-in-suspend.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${BP}:"
SRC_URI_append_ccimx6ulsbc = " file://0001-Remove-Update-partition.patch"
